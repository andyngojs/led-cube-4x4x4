# Keil uVision project cube4x4x4.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: cube4x4x4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c
