# Keil uVision project laptrinhcube.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: laptrinhcube +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 script.c
